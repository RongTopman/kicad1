# Repository RongTopman/kicad1

## KiCad design 运动控制卡/运动控制卡.kicad_pcb

Parts:
D17: SS54 60V/5A; MY
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
U9: 48V/3A; FUSE-SMD_L3.2-W1.6

Connections:
/接口/VIN+: D17.2 (A); also elsewhere on the board
/电源/VIN: U9.2; also elsewhere on the board
unnamed: D17.1 (K), U9.1

Notes on the sheet:
步进电机部分
CAN总线通信部分
485总线通信部分
模拟信号输出
以太网透传部分
电源部分

Parts:
C1: 100uF_100V; CP_Radial_D10.0mm_P5.00mm
C2, C3, C7: 220uF_10V; CP_Radial_D6.3mm_P2.50mm
C4: 104_Ceramic; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5, C6, C15: 104; C_0805_2012Metric
D18: 5V; SMB_L4.3-W3.6-LS5.4-RD
LDM1, LDM2: 1uH; 工字功率电感_1
TP1: 3V3; TestPoint_Plated_Hole_D2.0mm
TP2: 5V; TestPoint_Plated_Hole_D2.0mm
TP4: 2.5V; TestPoint_Plated_Hole_D2.0mm
U1: 48V-5V; URB4805YMD-10WR3
U2: SOT-223
U4: 2.5V; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C6.1, C7.1, TP1.1, U2.2 (VOUT), U2.4 (VOUT); also elsewhere on the board
+5V: C3.1, C4.1, C5.1, C15.1, D18.2 (A), LDM2.2, TP2.1, U2.3 (VIN), U4.2 (VIN); also elsewhere on the board
/MCU核心/VREF+: TP4.1, U4.6 (VOUT); also elsewhere on the board
/接口/VIN-: C1.2, U1.2 (VIN-); also elsewhere on the board
/电源/VIN: C1.1, U1.3 (VIN+); also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, C7.2, D18.1 (K), LDM1.2, U2.1 (GND); also elsewhere on the board
GNDA: C15.2, U4.4 (GND); also elsewhere on the board
unnamed: C2.1, LDM2.1, U1.4 (+VO)
unnamed: C2.2, LDM1.1, U1.5 (-VO)

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: LED; LED_0603_1608Metric
R12, R13, R17, R19, R21, R23, R25, R27, R29, R31, R33, R35: 500R; R_0603_1608Metric
R14, R15, R16, R18, R20, R22, R24, R26, R28, R30, R32, R34: 360R; R_0603_1608Metric
U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21: OPTO-SMD-4_L4.4-W4.1-P2.54-LS7.0-TL

Connections:
+5V: U10.4 (COL), U11.4 (COL), U12.4 (COL), U13.4 (COL), U14.4 (COL), U15.4 (COL), U16.4 (COL), U17.4 (COL), U18.4 (COL), U19.4 (COL), U20.4 (COL), U21.4 (COL); also elsewhere on the board
/MCU核心/DIR1: D2.2 (A), R15.1
/MCU核心/DIR2: D5.2 (A), R20.1
/MCU核心/DIR3: D8.2 (A), R26.1; also elsewhere on the board
/MCU核心/DIR4: D11.2 (A), R32.1; also elsewhere on the board
/MCU核心/EN1: D1.2 (A), R14.1
/MCU核心/EN2: D4.2 (A), R18.1
/MCU核心/EN3: D7.2 (A), R24.1; also elsewhere on the board
/MCU核心/EN4: D10.2 (A), R30.1; also elsewhere on the board
/MCU核心/PWM1: D3.2 (A), R16.1; also elsewhere on the board
/MCU核心/PWM2: D6.2 (A), R22.1; also elsewhere on the board
/MCU核心/PWM3: D9.2 (A), R28.1; also elsewhere on the board
/MCU核心/PWM4: D12.2 (A), R34.1; also elsewhere on the board
/steper/ST_DIR1: U11.3 (EM); also elsewhere on the board
/steper/ST_DIR2: U14.3 (EM); also elsewhere on the board
/steper/ST_DIR3: U17.3 (EM); also elsewhere on the board
/steper/ST_DIR4: U20.3 (EM); also elsewhere on the board
/steper/ST_EN1: U10.3 (EM); also elsewhere on the board
/steper/ST_EN2: U13.3 (EM); also elsewhere on the board
/steper/ST_EN3: U16.3 (EM); also elsewhere on the board
/steper/ST_EN4: U19.3 (EM); also elsewhere on the board
/steper/ST_PWM1: U12.3 (EM); also elsewhere on the board
/steper/ST_PWM2: U15.3 (EM); also elsewhere on the board
/steper/ST_PWM3: U18.3 (EM); also elsewhere on the board
/steper/ST_PWM4: U21.3 (EM); also elsewhere on the board
GND: R12.2, R13.2, R17.2, R19.2, R21.2, R23.2, R25.2, R27.2, R29.2, R31.2, R33.2, R35.2, U10.2 (CAT), U11.2 (CAT), U12.2 (CAT), U13.2 (CAT), U14.2 (CAT), U15.2 (CAT), U16.2 (CAT), U17.2 (CAT), U18.2 (CAT), U19.2 (CAT), U20.2 (CAT), U21.2 (CAT); also elsewhere on the board
unnamed: D1.1 (K), R35.1
unnamed: D2.1 (K), R12.1
unnamed: D3.1 (K), R13.1
unnamed: D4.1 (K), R17.1
unnamed: D5.1 (K), R19.1
unnamed: D6.1 (K), R21.1
unnamed: D7.1 (K), R23.1
unnamed: D8.1 (K), R25.1
unnamed: D9.1 (K), R27.1
unnamed: D10.1 (K), R29.1
unnamed: D11.1 (K), R31.1
unnamed: D12.1 (K), R33.1
unnamed: R14.2, U10.1 (AN)
unnamed: R15.2, U11.1 (AN)
unnamed: R16.2, U12.1 (AN)
unnamed: R18.2, U13.1 (AN)
unnamed: R20.2, U14.1 (AN)
unnamed: R22.2, U15.1 (AN)
unnamed: R24.2, U16.1 (AN)
unnamed: R26.2, U17.1 (AN)
unnamed: R28.2, U18.1 (AN)
unnamed: R30.2, U19.1 (AN)
unnamed: R32.2, U20.1 (AN)
unnamed: R34.2, U21.1 (AN)

Parts:
C19, C26: 104; C_0603_1608Metric
R1, R2, R3, R4, R5, R6, R7, R8: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5, U6: LM358; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C19.2, C26.2, U5.8 (VCC), U6.8 (VCC); also elsewhere on the board
/MCU核心/DAC_OU1: U5.3 (1IN+); also elsewhere on the board
/MCU核心/DAC_OUT2: U5.5 (2IN+); also elsewhere on the board
/MCU核心/DAC_OUT3: U6.3 (1IN+); also elsewhere on the board
/MCU核心/DAC_OUT4: U6.5 (2IN+); also elsewhere on the board
/接口/DAC_1: R7.2, U5.1 (1OUT); also elsewhere on the board
/接口/DAC_2: R3.2, U5.7 (2OUT); also elsewhere on the board
/接口/DAC_3: R5.2, U6.1 (1OUT); also elsewhere on the board
/接口/DAC_4: R1.2, U6.7 (2OUT); also elsewhere on the board
GNDA: C19.1, C26.1, R2.1, R4.1, R6.1, R8.1, U5.4 (GND), U6.4 (GND); also elsewhere on the board
unnamed: R7.1, R8.2, U5.2 (1IN-)
unnamed: R3.1, R4.2, U5.6 (2IN-)
unnamed: R5.1, R6.2, U6.2 (1IN-)
unnamed: R1.1, R2.2, U6.6 (2IN-)

Parts:
C20: 104; C_0603_1608Metric
R9: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 510R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U7: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: R10.2; also elsewhere on the board
+5V: C20.1, U7.3 (VCC); also elsewhere on the board
/MCU核心/CAN_RX: U7.4 (RXD); also elsewhere on the board
/MCU核心/CAN_TX: U7.1 (TXD); also elsewhere on the board
/can总线/CAN+: R9.2, U7.7 (CANH); also elsewhere on the board
/can总线/CAN-: R9.1, U7.6 (CANL); also elsewhere on the board
GND: C20.2, U7.2 (GND), U7.8 (S); also elsewhere on the board
unnamed: R10.1, U7.5 (VIO)

Parts:
C21: 104; C_0603_1608Metric
J1, J2: Screw_Terminal_01x08; TerminalBlock_RND_205-00238_1x08_P5.08mm_Horizontal
J4, J5, J6, J7: Screw_Terminal_01x04; TerminalBlock_RND_205-00278_1x04_P5.00mm_Vertical
U8: ZQWL-GE145S/ZQWL-GE145S; ZQWL-GE145S_ZQWL-GE105S

Connections:
+3V3: C21.2, U8.8 (3.3V); also elsewhere on the board
/MCU核心/USART_RX: U8.3 (RXD); also elsewhere on the board
/MCU核心/USART_TX: U8.2 (TXD); also elsewhere on the board
/RS485/485+: J2.6; also elsewhere on the board
/RS485/485-: J2.5; also elsewhere on the board
/can总线/CAN+: J2.7; also elsewhere on the board
/can总线/CAN-: J2.8; also elsewhere on the board
/steper/ST_DIR1: J4.2; also elsewhere on the board
/steper/ST_DIR2: J5.2; also elsewhere on the board
/steper/ST_DIR3: J6.3; also elsewhere on the board
/steper/ST_DIR4: J7.3; also elsewhere on the board
/steper/ST_EN1: J4.3; also elsewhere on the board
/steper/ST_EN2: J5.3; also elsewhere on the board
/steper/ST_EN3: J6.2; also elsewhere on the board
/steper/ST_EN4: J7.2; also elsewhere on the board
/steper/ST_PWM1: J4.1; also elsewhere on the board
/steper/ST_PWM2: J5.1; also elsewhere on the board
/steper/ST_PWM3: J6.4; also elsewhere on the board
/steper/ST_PWM4: J7.4; also elsewhere on the board
/接口/DAC_1: J1.1; also elsewhere on the board
/接口/DAC_2: J1.2; also elsewhere on the board
/接口/DAC_3: J1.3; also elsewhere on the board
/接口/DAC_4: J1.4; also elsewhere on the board
/接口/VIN+: J1.7; also elsewhere on the board
/接口/VIN-: J1.8; also elsewhere on the board
GND: C21.1, J4.4, J5.4, J6.1, J7.1, U8.7 (GND), U8.14 (PGND), U8.15 (PGND); also elsewhere on the board
GNDA: J1.5; also elsewhere on the board

Notes on the sheet:
以太网透传
左侧端子

Parts:
C8, C10, C11, C12, C13, C16, C17, C22, C23: 104; C_0603_1608Metric
C9: IUF; C_0603_1608Metric
C14: 4.7UF; C_0603_1608Metric
C18: 1uf; C_0603_1608Metric
J3: Conn_02x05_Counter_Clockwise; PinHeader_2x05_P2.54mm_Vertical
L1, L2: 600 R@100MHz; R_0603_1608Metric
R11: 10K; R_0603_1608Metric
R41: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP5: GNDA; TestPoint_Plated_Hole_D2.0mm
TP6: GND; TestPoint_Plated_Hole_D2.0mm
U3: STM32G474RETx; LQFP-64_10x10mm_P0.5mm
Y1: 24M; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: C10.1, C11.1, C12.1, C13.1, C14.1, J3.3, L1.1, U3.1 (VBAT), U3.16 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD); also elsewhere on the board
+5V: J3.1; also elsewhere on the board
/MCU核心/CAN_RX: U3.45 (PA11); also elsewhere on the board
/MCU核心/CAN_TX: U3.46 (PA12); also elsewhere on the board
/MCU核心/DAC_OU1: U3.14 (PA2); also elsewhere on the board
/MCU核心/DAC_OUT2: U3.25 (PB1); also elsewhere on the board
/MCU核心/DAC_OUT3: U3.18 (PA4); also elsewhere on the board
/MCU核心/DAC_OUT4: U3.19 (PA5); also elsewhere on the board
/MCU核心/DIR3: U3.35 (PB13); also elsewhere on the board
/MCU核心/DIR4: U3.37 (PB15); also elsewhere on the board
/MCU核心/EN3: U3.34 (PB12); also elsewhere on the board
/MCU核心/EN4: U3.36 (PB14); also elsewhere on the board
/MCU核心/PWM1: U3.38 (PC6); also elsewhere on the board
/MCU核心/PWM2: U3.39 (PC7); also elsewhere on the board
/MCU核心/PWM3: U3.40 (PC8); also elsewhere on the board
/MCU核心/PWM4: U3.41 (PC9); also elsewhere on the board
/MCU核心/RS485_RX: U3.33 (PB11); also elsewhere on the board
/MCU核心/RS485_TX: U3.30 (PB10); also elsewhere on the board
/MCU核心/USART_RX: U3.23 (PC5); also elsewhere on the board
/MCU核心/USART_TX: U3.22 (PC4); also elsewhere on the board
/MCU核心/VREF+: C16.2, L2.1; also elsewhere on the board
BOOT0: J3.10, U3.62 (PB9)
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C22.1, C23.2, J3.5, R11.2, R41.1, TP6.1, U3.15 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), Y1.2, Y1.4; also elsewhere on the board
GNDA: C8.2, C9.2, C16.1, C17.1, C18.1, R41.2, TP5.1, U3.27 (VSSA); also elsewhere on the board
unnamed: J3.8, R11.1
unnamed: C22.2, U3.5 (PF0), Y1.3
unnamed: C23.1, U3.6 (PF1), Y1.1
unnamed: C17.2, C18.2, L2.2, U3.28 (VREF+)
RST: J3.6, U3.7 (PG10)
SWCLK: J3.7, U3.50 (PA14)
SWDIO: J3.9, U3.49 (PA13)
UART4_RX: J3.2, U3.53 (PC11)
UART4_TX: J3.4, U3.52 (PC10)
VDDA: C8.1, C9.1, L1.2, U3.29 (VDDA)

Notes on the sheet:
模拟地和数字地 使用600R@100MHz 的磁珠连接
模拟电源和数字电源 使用600R@100MHz 的磁珠连接
如果需要将BOOT0拉低 请将6脚7脚用跳线帽短接
DEBUG
VREF+
25M
ABOUT POWER

Parts:
C24: 102; C_0603_1608Metric
C25: 104; C_0603_1608Metric
D13: MBR0520; D_SOD-123
D14, D15, D16: SMB_L4.6-W3.6-LS5.3-BI
Q1: S8050; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
R36: 20K; R_0603_1608Metric
R37: 10K; R_0603_1608Metric
R38, R39: 360R; R_0603_1608Metric
R40: 120R; R_0603_1608Metric
U22: SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL

Connections:
+3V3: C25.1, R37.1, R39.1, U22.8 (VCC); also elsewhere on the board
/MCU核心/RS485_RX: D13.1 (K), R36.2, U22.4 (D); also elsewhere on the board
/MCU核心/RS485_TX: U22.1 (R); also elsewhere on the board
/RS485/485+: D14.1 (K), D16.1 (K), R39.2, R40.1, U22.6 (A/Y); also elsewhere on the board
/RS485/485-: D14.2 (A), D15.2 (A), R38.1, R40.2, U22.7 (B/Z); also elsewhere on the board
GND: C24.1, C25.2, D15.1 (K), D16.2 (A), Q1.1 (E), R38.2, U22.5 (GND); also elsewhere on the board
unnamed: C24.2, D13.2 (A), Q1.2 (B), R36.1
unnamed: Q1.3 (C), R37.2, U22.2 (RE), U22.3 (DE)

Board: 4 copper layers, 90.0 x 120.0 mm, 127 parts (6 on the bottom side), 95 nets.

## Commit log

2024-02-01 开仓大吉
